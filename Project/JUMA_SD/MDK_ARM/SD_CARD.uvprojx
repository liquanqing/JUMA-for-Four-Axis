# Keil uVision project SD_CARD.uvprojx, settings and files
target Flash (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SDCARD
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_USB_FS,__FPU_USED
  c misc: --c99
  c include: ..\inc;..\..\..\Inc_Lib;..\..\..\Driver\BSP;..\..\..\Driver\BSP\CONNON_V2;..\..\..\Driver\BSP\VCP;..\..\..\Driver\BSP\I2C;..\..\..\Driver\BSP\HUM_TEMP;..\..\..\Driver\BSP\IMU;..\..\..\Driver\BSP\MAGNETO;..\..\..\Driver\BSP\SD_CARD;..\..\..\Driver\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Driver\CMSIS\Include;..\..\..\Driver\STM32F4xx_HAL_Driver\Inc;..\..\..\Driver\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\Third_Party\FatFs;..\..\..\Middlewares\Third_Party\FatFs\option;..\..\..\Middlewares\Third_Party\FatFs\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group App
    ../src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../../../Driver/BSP/ITM_DEBUG/: INC_ITM.c
  group Driver/BSP/CONNON_V2
    ../../../Driver/BSP/CONNON_V2/: connon_v2.c
  group Driver/BSP/VCP
    ../../../Driver/BSP/VCP/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Driver/BSP/I2C
    ../../../Driver/BSP/I2C/: I2CSoft.c
  group Driver/BSP/Sensor
    ../../../Driver/BSP/HUM_TEMP/: HTS221.c
    ../../../Driver/BSP/IMU/: lsm6ds3.c
    ../../../Driver/BSP/MAGNETO/: lsm303agr.c LSM303AGR_ACC_driver.c LSM303AGR_MAG_driver.c
  group Driver/BSP/SD_CARD
    ../../../Driver/BSP/SD_CARD/: stm324xg_eval_sd.c
  group Driver/CMSIS
    ../../../Driver/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Driver/STM32F4xx_HAL_Driver
    ../../../Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c stm32f4xx_hal_smartcard.c stm32f4xx_ll_sdmmc.c
  group IncLib
    ../../../Inc_Lib/: Queue.c
  group Mid/ST/USB_Device/core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Mid/ST/USB_Device/Class
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Mid/ThirdParty/Fatfs
    ../../../Middlewares/Third_Party/FatFs/: diskio.c ff.c ff_gen_drv.c
    ../../../Middlewares/Third_Party/FatFs/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.1.0
